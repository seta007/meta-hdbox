SRCDATE = "20180820"

require hdbox-bootargs.inc

SRC_URI[md5sum] = "7899bf83e4f866c73c791deba29d239a"
SRC_URI[sha256sum] = "4f18cbc53b8e2f93019084b6807d8f0feadbdbac66df87e5be92f4b1a6c44d4c"

COMPATIBLE_MACHINE = "^(reborn)$"
