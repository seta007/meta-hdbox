SRCDATE = "20180820"

require hdbox-partitions.inc

SRC_URI[md5sum] = "1c641a938a2fa2b4dc1f06861c259fed"
SRC_URI[sha256sum] = "788735e2442fcc9b324d35f88e610a06c35e810fd90c927f6e0e4b9591684b4e"

COMPATIBLE_MACHINE = "^(reborn)$"
