SRCDATE = "20180820"

require hdbox-libs.inc

SRC_URI[md5sum] = "ca1e473b9395a6e43ae9b4a0ac95e4ff"
SRC_URI[sha256sum] = "8424c534ab52230dd7a335ae523088935456f0fc3a0bd8e58b73cf55d6d792a7"

COMPATIBLE_MACHINE = "^(reborn)$"
