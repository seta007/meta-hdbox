SRCDATE = "20180820"

require hdbox-bootlogo.inc

SRC_URI[md5sum] = "dd428757d5418a1823fdb9b8caf493d9"
SRC_URI[sha256sum] = "a9cc32ff643e21f7a40074619b1fb3a573b364eb5a36bcc4b92705caab3634b4"

COMPATIBLE_MACHINE = "^(reborn)$"
