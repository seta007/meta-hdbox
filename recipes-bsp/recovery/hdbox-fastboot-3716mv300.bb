SRCDATE = "20180820"

require hdbox-fastboot.inc

SRC_URI[md5sum] = "2d4da65d8a7dd0883ff7e591e5878e1e"
SRC_URI[sha256sum] = "fc73a4b5aa6ed383875dc9b6652848d98fa031adaf67f86a37f73557e9902624"

COMPATIBLE_MACHINE = "^(reborn)$"
