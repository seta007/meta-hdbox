SRCDATE = "20180820"

require hdbox-recovery.inc

SRC_URI[md5sum] = "ac4ca21703feecad21c5b97767a3780a"
SRC_URI[sha256sum] = "57a32c30e0d3ba1c0be7e76d44a2c7a1a94e90da348ef5daec0034176681ca72"

COMPATIBLE_MACHINE = "^(reborn)$"
